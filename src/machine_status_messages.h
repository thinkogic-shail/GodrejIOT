#pragma once
#include <stdint.h>
// Messages mirrored from Android Commands.getMachineStatusMessage.
inline const char* machineStatusMessage(uint32_t level, uint32_t number) {
  if (level == 0) return "POWER ON";
  if (level == 1 && number == 1) return "REFILLING WATER 1";
  if (level == 1 && number == 2) return "REFILLING WATER 2";
  if (level == 1 && number == 3) return "HEATING 1";
  if (level == 1 && number == 4) return "HEATING 2";
  if (level == 1 && number == 5) return "TEMPERATURE TOO HIGH 1";
  if (level == 1 && number == 6) return "TEMPERATURE TOO HIGH 2";
  if (level == 1 && number == 7) return "TEMPERATURE TOO LOW 1";
  if (level == 1 && number == 8) return "TEMPERATURE TOO LOW 2";
  if (level == 1 && number == 9) return "TEMPERATURE LOW 3";
  if (level == 1 && number == 10) return "TEMPERATURE TOO HIGH 3";
  if (level == 1 && number == 11) return "TEMPERATURE TOO LOW 3";
  if (level == 1 && number == 12) return "DRIP TRAY FULL";
  if (level == 1 && number == 13) return "NO DRIP TRAY";
  if (level == 1 && number == 14) return "MACHINE LOCKED";
  if (level == 1 && number == 15) return "STANDBY";
  if (level == 1 && number == 16) return "ENERGY SAVE MODE";
  if (level == 1 && number == 17) return "HEATING...";
  if (level == 1 && number == 18) return "CANISTER x EMPTY";
  if (level == 1 && number == 19) return "FLAVOR LOCKED!";
  if (level == 1 && number == 20) return "PLACE CUP !!";
  if (level == 1 && number == 21) return "FILLING WATER !";
  if (level == 1 && number == 22) return "MAINTENANCE MODE";
  if (level == 1 && number == 23) return "FUNCTION KEY x";
  if (level == 1 && number == 24) return "PLEASE CLEAN";
  if (level == 1 && number == 25) return "PRE-SELECTION";
  if (level == 1 && number == 26) return "PLEASE TRY AGAIN";
  if (level == 1 && number == 27) return "CLEANING ESPRESSO";
  if (level == 1 && number == 28) return "INIT TEA BREWER";
  if (level == 1 && number == 29) return "BUTTON DISABLED!";
  if (level == 1 && number == 30) return "SHOW CARD";
  if (level == 1 && number == 31) return "INSERT COIN !";
  if (level == 1 && number == 32) return "INSERT TOKEN !";
  if (level == 1 && number == 33) return "LOW CREDIT!";
  if (level == 1 && number == 34) return "MULTI-CUP EXIT";
  if (level == 1 && number == 35) return "REMOVE CUP!!";
  if (level == 1 && number == 36) return "WASTE BUCKET FULL";
  if (level == 1 && number == 37) return "RUN CLEAN BREWER";
  if (level == 1 && number == 42) return "AUTO CLEANING";
  if (level == 1 && number == 43) return "AUTO CLEAN END";
  if (level == 1 && number == 44) return "Timeout error: No smart card detected.";
  if (level == 2 && number == 1) return "T SENSOR ERROR 1";
  if (level == 2 && number == 2) return "T SENSOR ERROR 2";
  if (level == 2 && number == 3) return "T SENSOR ERROR 3";
  if (level == 2 && number == 4) return "KEY xx SHORT!";
  if (level == 2 && number == 5) return "\"TOKEN BLOCKED!\nCOIN BLOCKED!\nREADER SHORT!\"";
  if (level == 2 && number == 6) return "CALL SERVICE!";
  if (level == 2 && number == 7) return "SMART CARD ERROR!";
  if (level == 2 && number == 8) return "COIN MECH ERROR!";
  if (level == 2 && number == 9) return "PLS CLEAN BREWER";
  if (level == 2 && number == 10) return "ESP TANK EMPTY!";
  if (level == 2 && number == 11) return "TEA BREWER JAM!";
  if (level == 2 && number == 12) return "BILL VAL ERROR!";
  if (level == 2 && number == 13) return "NO COFFEE BEANS";
  if (level == 2 && number == 14) return "BEAN SENSE ERROR";
  if (level == 2 && number == 15) return "GRINDER OVERLOAD";
  if (level == 2 && number == 16) return "GRINDER MOTOR BLOCK";
  if (level == 2 && number == 17) return "GRINDER MOTOR TIME";
  if (level == 2 && number == 18) return "GRINDER ERR STARTUP";
  if (level == 2 && number == 19) return "GRINDER UNKNOWN ERROR";
  if (level == 3 && number == 1) return "SUPPLY WATER 1";
  if (level == 3 && number == 2) return "SUPPLY WATER 2";
  if (level == 3 && number == 3) return "HEATING FAILED 1";
  if (level == 3 && number == 4) return "HEATING FAILED 2";
  if (level == 3 && number == 5) return "WATER LEVEL ERR1";
  if (level == 3 && number == 6) return "WATER LEVEL ERR2";
  if (level == 3 && number == 7) return "HEATING FAILED 3";
  if (level == 3 && number == 8) return "CLEANING REQUIRED";
  if (level == 4 && number == 1) return "Machine Ready";
  if (level == 4 && number == 2) return "Processing...";
  if (level == 4 && number == 3) return "ENJOY DRINK !!";
  if (level == 4 && number == 4) return "Emergency Stop, Remove Cup";
  if (level == 4 && number == 5) return "CLEANING...";
  if (level == 4 && number == 6) return "MACHINE TEST ON!";
  if (level == 4 && number == 7) return "\"TEST COMPLETED!\nTEST TERMINATED!\"";
  return "UNKNOWN STATUS";
}
